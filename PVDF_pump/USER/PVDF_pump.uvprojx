# Keil uVision project PVDF_pump.uvprojx, settings and files
target PVDF_pump (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PVDF_pump +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;.\BSP\ADC;.\BSP\KEY;.\BSP\MOD;.\BSP\PID;.\BSP\LED;.\BSP\TIMER;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\CORE;..\STM32F10x_FWLib\inc;.\BSP\LCD_SPI;.\BSP\TOUCH;.\BSP\IIC;.\BSP\24CXX;.\BSP\DAC;.\BSP\NVIC;.\BSP\DMA;.\cJSON
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s GUI.c
  group BSP
    ./BSP/PID/: pid.c
    ./BSP/KEY/: key.c
    ./BSP/LED/: led.c
    ./BSP/MOD/: mod.c
    ./BSP/TIMER/: timer.c
    ./BSP/LCD_SPI/: lcd.c
    ./BSP/TOUCH/: touch.c
    ./BSP/NVIC/: nvic.c
    ./BSP/ADC/: adc.c
    ./BSP/DMA/: dma.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_dac.c
  group README
    ../: README.TXT
